# Keil uVision project Project.uvprojx, settings and files
target Azure_Motor (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Azure_Motor +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L475xx,USE_HAL_DRIVER,USE_STM32L475E_IOT01,NO_LOGGING=1,EINVAL=-1,ENOMEM=EINVAL,USE_GENERICACCESSKEY_IOTHUB=0,REFCOUNT_ATOMIC_DONTCARE=1,DONT_USE_UPLOADTOBLOB=1,USE_MBED_TLS,USE_WIFI,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,STRINGS_C_SPRINTF_BUFFER_SIZE,AZURE_MOTOR
  c misc: --gnu --diag_suppress 938 --diag_suppress 177 --diag_suppress 1  --diag_suppress 951
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L475E-IOT01;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/hts221;../../../../../../Drivers/BSP/Components/lis3mdl;../../../../../../Drivers/BSP/Components/lps22hb;../../../../../../Drivers/BSP/Components/lsm6dsl;../../../../../../Drivers/BSP/Components/lsm303agr;../../../../../../Drivers/BSP/Components/M24SR;../../../../../../Drivers/BSP/Components/L6470;../../../../../../Drivers/BSP/Components/es_wifi;../../../../../../Drivers/BSP/X-NUCLEO-IHM02A1;../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/umqtt/inc;../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/iothub_client/inc;../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/c-utility/inc;../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/c-utility/pal/generic;../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/serializer/inc;../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/parson;../../../../../../Middlewares/Third_Parties/mbedtls/include;../../../../../../Middlewares/ST/lib_NDEF/inc;../../../../../../Middlewares/ST/STM32_MetaDataManager;../../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Doc
    ../../: readme.txt
  group Application/User
    ../../Src/: stm32l4xx_hal_msp.c stm32l4xx_it.c main.c agenttime_STM32Cube.c azure_base64.c azure_sha1.c console.c es_wifi_io.c m24sr_wrapper.c mbedtls_net.c net.c net_tcp_wifi.c net_tls_mbedtls.c platform_STM32Cube_IoT01L475VG.c STM32CubeRTCInterface.c tickcounter_STM32Cube.c timingSystem.c tlsio_mbedtls_STM32Cube_IoT01L475VG.c wifi.c az_socketio_mbed.c az_tcpsocketconnection_c_STM32Cube.c AzureClient_mqtt_Motor.c params.c
    ../../../../../../Utilities/RegistrationAgentInternal/: RegistrationAgentInternal.c
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Drivers/CMSIS
    ../../Src/: system_stm32l4xx.c
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01_accelero.c stm32l475e_iot01_gyro.c stm32l475e_iot01_hsensor.c stm32l475e_iot01_magneto.c stm32l475e_iot01_psensor.c stm32l475e_iot01_tsensor.c
  group Drivers/BSP/Component
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c
    ../../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c
    ../../../../../../Drivers/BSP/Components/M24SR/: m24sr_v1.1.c
    ../../../../../../Drivers/BSP/Components/L6470/: L6470.c
  group Drivers/BSP/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c
  group Middlewares/AzureIOT
    ../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/c-utility/src/: buffer.c constbuffer.c constmap.c crt_abstractions.c doublylinkedlist.c hmac.c hmacsha256.c map.c optionhandler.c sastoken.c sha224.c sha384-512.c singlylinkedlist.c string_tokenizer.c strings.c urlencode.c usha.c vector.c xio.c
    ../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/iothub_client/src/: iothub_client_authorization.c iothub_client_ll.c iothub_message.c iothubtransport_mqtt_common.c iothubtransportmqtt.c iothub_client_diagnostic.c iothub_client_retry_control.c
    ../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/parson/: parson.c
    ../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/serializer/src/: agenttypesystem.c codefirst.c commanddecoder.c datamarshaller.c datapublisher.c iotdevice.c jsondecoder.c jsonencoder.c methodreturn.c multitree.c schema.c schemalib.c
    ../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/umqtt/src/: mqtt_client.c mqtt_codec.c mqtt_message.c
  group Middlewares/LibNDEF
    ../../../../../../Middlewares/ST/lib_NDEF/src/: lib_NDEF.c lib_NDEF_Text.c lib_NDEF_URI.c lib_NDEF_Wifi.c lib_TagType4.c lib_NDEF_Email.c lib_NDEF_Geo.c lib_NDEF_SMS.c lib_NDEF_Vcard.c lib_NDEF_MyApp.c lib_NDEF_AAR.c
  group Middlewares/mbedTLS
    ../../../../../../Middlewares/Third_Parties/mbedtls/library/: aes.c aesni.c asn1parse.c base64.c bignum.c cipher.c cipher_wrap.c ctr_drbg.c debug.c ecdh.c ecp.c ecp_curves.c entropy.c gcm.c md.c md_wrap.c oid.c pem.c pk.c pk_wrap.c platform.c rsa.c sha1.c sha256.c sha512.c ssl_ciphersuites.c ssl_cli.c ssl_tls.c x509.c x509_crl.c x509_crt.c pkparse.c
  group Middlewares/MetaDataManager
    ../../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group Drivers/BSP/X-NUCLEO-IHM02A1
    ../../../../../../Drivers/BSP/X-NUCLEO-IHM02A1/: xnucleoihm02a1.c
software components: CMSIS:CORE 4.3.0
