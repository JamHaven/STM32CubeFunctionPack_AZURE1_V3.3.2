# Keil uVision project Project.uvprojx, settings and files
target STM32F429ZI_Nucleo_144 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F429ZI_Nucleo_144 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM32F4XX_NUCLEO,STM32_NUCLEO,NO_LOGGING=1,USE_GENERICACCESSKEY_IOTHUB=0,DONT_USE_UPLOADTOBLOB,REFCOUNT_ATOMIC_DONTCARE,USE_MBED_TLS,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,AZURE_NFC04A1,STRINGS_C_SPRINTF_BUFFER_SIZE
  c misc: --gnu --no_conditionalize --diag_suppress 177 --diag_suppress 1  --diag_suppress 951
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F4xx_Nucleo_144;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsl;..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr;..\..\..\..\..\..\Drivers\BSP\Components\ST25DV;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A2;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_NFC04A1;..\..\..\..\..\..\Middlewares\Third_Parties\Azure-IoT-SDK-C\umqtt\inc;..\..\..\..\..\..\Middlewares\Third_Parties\Azure-IoT-SDK-C\iothub_client\inc;..\..\..\..\..\..\Middlewares\Third_Parties\Azure-IoT-SDK-C\c-utility\inc;..\..\..\..\..\..\Middlewares\Third_Parties\Azure-IoT-SDK-C\c-utility\pal\generic;..\..\..\..\..\..\Middlewares\Third_Parties\Azure-IoT-SDK-C\serializer\inc;..\..\..\..\..\..\Middlewares\Third_Parties\Azure-IoT-SDK-C\parson;..\..\..\..\..\..\Middlewares\ST\lib_NDEF_V5\inc;..\..\..\..\..\..\Middlewares\ST\STM32_MetaDataManager;..\..\..\..\..\..\Middlewares\Third_Parties\mbedtls\include;..\..\..\..\..\..\Middlewares\Third_Parties\LwIP\src\include;..\..\..\..\..\..\Middlewares\Third_Parties\LwIP\system;..\..\..\..\..\..\Middlewares\Third_Parties\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\..\Middlewares\Third_Parties\FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\Third_Parties\FreeRTOS\Source\portable\Keil;..\..\..\..\..\..\Middlewares\Third_Parties\FreeRTOS\Source\portable\MemMang;..\..\..\..\..\..\Middlewares\Third_Parties\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\Utilities\RegistrationAgentInternal
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Doc
    ../: readme.txt
  group Example/User
    ../../Src/: agenttime_STM32Cube.c azure_base64.c azure_sha1.c AzureClient_mqtt_DM_TM.c console.c ethernetif.c HWAdvanceFeatures.c main.c OTA.c platform_STM32Cube_NucleoF429ZI.c socketio_STM32Cube_lwIP.c STM32CubeRTCInterface.c stm32f4xx_hal_msp.c stm32f4xx_it.c tickcounter_STM32Cube.c timingSystem.c TLocalBuffer.c tlsio_mbedtls_STM32Cube_Nucleo.c
    ../../../../../../Utilities/RegistrationAgentInternal/: RegistrationAgentInternal.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: LSM6DSL_ACC_GYRO_driver.c LSM6DSL_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/ST25DV/: st25dv.c
  group Drivers/BSP/Nucleo-144
    ../../../../../../Drivers/BSP/STM32F4xx_Nucleo_144/: stm32f4xx_I2C.c stm32f4xx_nucleo_144.c stm32f4xx_UART.c
  group Drivers/BSP/IKS01A2
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_accelero.c x_nucleo_iks01a2_gyro.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_magneto.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Drivers/BSP/NFC04A1
    ../../../../../../Drivers/BSP/X_NUCLEO_NFC04A1/: x_nucleo_nfc04a1.c x_nucleo_nfc04a1_nfctag.c
  group STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_crc.c
  group Middlewares/AzureIoT/c-utility
    ../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/c-utility/src/: buffer.c constbuffer.c constmap.c crt_abstractions.c doublylinkedlist.c hmac.c hmacsha256.c map.c optionhandler.c sastoken.c sha224.c sha384-512.c singlylinkedlist.c string_tokenizer.c strings.c urlencode.c usha.c vector.c xio.c
  group Middlewares/AzureIoT/iothub_client
    ../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/iothub_client/src/: iothub_client_authorization.c iothub_client_ll.c iothub_message.c iothubtransport_mqtt_common.c iothubtransportmqtt.c iothub_client_diagnostic.c iothub_client_retry_control.c
  group Middlewares/AzureIoT/parson
    ../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/parson/: parson.c
  group Middlewares/AzureIoT/serializer
    ../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/serializer/src/: agenttypesystem.c codefirst.c commanddecoder.c datamarshaller.c datapublisher.c iotdevice.c jsondecoder.c jsonencoder.c methodreturn.c multitree.c schema.c schemalib.c
  group Middlewares/AzureIoT/umqtt
    ../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/umqtt/src/: mqtt_client.c mqtt_codec.c mqtt_message.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Parties/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Parties/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../Middlewares/Third_Parties/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../Middlewares/Third_Parties/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/LibNDEF_V5
    ../../../../../../Middlewares/ST/lib_NDEF_V5/src/: lib_NDEF.c lib_NDEF_Text.c lib_NDEF_URI.c tagtype5_wrapper.c
  group Middlewares/LwIP/api
    ../../../../../../Middlewares/Third_Parties/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LwIP/core
    ../../../../../../Middlewares/Third_Parties/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../../Middlewares/Third_Parties/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/LwIP/netif
    ../../../../../../Middlewares/Third_Parties/LwIP/src/netif/: ethernet.c
    ../../../../../../Middlewares/Third_Parties/LwIP/src/netif/ppp/: pppapi.c
    ../../../../../../Middlewares/Third_Parties/LwIP/system/OS/: sys_arch.c
  group Middlewares/mbedTLS
    ../../../../../../Middlewares/Third_Parties/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c CMakeLists.txt ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group Middlewares/MetaDataManager
    ../../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
software components: CMSIS:CORE 4.1.0
